# Repository PeraZver/80W-Audio-Amplifier

File README.MD:

# 80W Audio Amplifier

From the book High Power Audio Amplifier Construction Manual
Overal THD is approximately 0.001 %.
80 W RMS into the 8 Ohm speaker. 

Pero, January 2019

## KiCad design AudioAmp.kicad_pcb

Parts:
C1, C2, C5: 47u; CP_Radial_D10.0mm_P5.00mm
C3, C4: 220u; CP_Radial_D22.0mm_P10.00mm_SnapIn
C6: 220u; CP_Radial_D10.0mm_P5.00mm
C7: 150p; C_Rect_L10.0mm_W3.0mm_P7.50mm_MKS4
C8: 5p; C_Disc_D6.0mm_W2.5mm_P5.00mm
C9: 300p; C_Rect_L10.0mm_W3.0mm_P7.50mm_MKS4
C10: 47u
C11, C12, C13: 100n; C_Rect_L10.0mm_W4.0mm_P7.50mm_MKS4
D1, D2, D3: 1N4148
F1, F2: Fuse; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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; Rating 3A
J1, J2, J3, J4, J5, J6, J7, J8: Conn_01x01; 216843-1
L1: 1u
Q1, Q3, Q5, Q6, Q13: 2N5401; TO-92_Inline
Q2, Q4, Q7, Q12: 2N5551; TO-92_Inline
Q8, Q10, Q11, Q14: 2SD669; TO-126-3_Vertical
Q9, Q15: 2SB649; TO-126-3_Vertical
Q16: 2SA1302; TO-3P-3_Vertical
Q17: 2SC3281; TO-3P-3_Vertical
R1, R5, R19, R20, R23, R24, R31, R32: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R6: 68R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 150R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R8, R9, R11: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R14, R15, R16, R17: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10, R12: 330R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 2K2; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 820R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R21: 15R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R22: 47R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R25, R28: 15K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R26, R27: 120R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R29, R30: 270R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R33, R34: 0R22; R_Radial_Power_L13.0mm_W9.0mm_P5.00mm; Tolerance ±5%; Part Number SQMW5R22J
R35, R36: 10R; R_Axial_DIN0516_L15.5mm_D5.0mm_P30.48mm_Horizontal; Tolerance ±5 %; Part Number CFR200J10R
RV1: 1K; Potentiometer_Piher_PT-10-V10_Vertical

Connections:
/VCC_FUSED: C4.1, C5.1, C11.2, F2.2, Q6.1 (E), Q16.3 (E), R3.1, R20.1, R25.1, R31.1
/VSS_FUSED: C3.2, C13.1, F1.2, Q7.1 (E), Q17.3 (E), R2.2, R6.2, R13.2, R17.2, R22.2, R28.2, R32.2
GND: C3.1, C4.2, C6.2, C11.1, C12.1, C13.2, D1.2 (A), J5.1, J6.1, J7.1, J8.1, Q8.2 (C), R4.2, R9.2
IN: C1.1, J1.1
unnamed: C1.2, C2.2
unnamed: C2.1, Q1.2 (B), R4.1
unnamed: C5.2, R8.2, R9.1
unnamed: C6.1, D1.1 (K), R10.2
unnamed: C7.1, C9.2, R13.1
unnamed: C7.2, Q1.3 (C), Q2.3 (C), Q7.3 (C), Q8.3 (B)
unnamed: C8.1, L1.1, Q12.1 (E), Q13.1 (E), R11.1, R26.2, R27.1, R33.2, R34.1, R35.1, R36.2
unnamed: C8.2, R12.1
unnamed: C10.1, Q9.2 (C), R18.1, R21.1
unnamed: C9.1, C10.2, Q10.1 (E), Q11.2 (C), R23.2, RV1.2, RV1.3
unnamed: C12.2, R35.2
unnamed: D2.1 (K), Q12.3 (C)
unnamed: D2.2 (A), Q14.3 (B), R24.1
unnamed: D3.1 (K), Q15.3 (B), R23.1
unnamed: D3.2 (A), Q13.3 (C)
unnamed: Q1.1 (E), R1.2
unnamed: Q2.1 (E), R2.1
unnamed: Q2.2 (B), Q4.2 (B), Q4.3 (C), Q5.3 (C)
unnamed: Q3.1 (E), R3.2
unnamed: Q3.2 (B), R7.2
unnamed: Q3.3 (C), R1.1, R5.1
unnamed: Q4.1 (E), R6.1
unnamed: Q5.1 (E), R5.2
unnamed: Q5.2 (B), R10.1, R11.2, R12.2
unnamed: Q6.2 (B), R14.2
unnamed: Q6.3 (C), R7.1, R8.1, R16.2
unnamed: Q7.2 (B), R15.2
unnamed: Q9.1 (E), R14.1, R20.2
unnamed: Q9.3 (B), R16.1
unnamed: Q10.2 (C), R21.2, R24.2
unnamed: Q10.3 (B), R18.2, R19.1
unnamed: Q11.1 (E), R15.1, R22.1
unnamed: Q8.1 (E), Q11.3 (B), R17.1
unnamed: Q12.2 (B), R25.2, R26.1, R29.2
unnamed: Q13.2 (B), R27.2, R28.1, R30.2
unnamed: Q14.1 (E), Q16.2 (C), R29.1, R33.1
unnamed: Q14.2 (C), Q16.1 (B), R31.2
unnamed: Q15.1 (E), Q17.2 (C), R30.1, R34.2
unnamed: Q15.2 (C), Q17.1 (B), R32.1
unnamed: R19.2, RV1.1
OUT: J2.1, L1.2, R36.1
VCC: F2.1, J3.1
VSS: F1.1, J4.1

Notes on the sheet:
Complementary BJTs 2N5551 - 2N5401, Ic = 0.6A, TO-92 2SD669 - 2SB649, Ic = 1.5A, TO-126 2SA1302 - 2SC3281, Ic = 15A, TO-3P
Darlington VA stage with current limit
Input stage with current mirror and current source
Class B OPS with complimentary feedback
Current source for diff. pair
Current source for VA
Single slope current limiter
OPS Bias
Ilim = .65/.3/.22 = 9.8A
Ic=6.5mA

Board: 2 copper layers, 160.0 x 100.0 mm, 80 parts (0 on the bottom side), 47 nets.

## KiCad design Preamp/Preamp.kicad_pcb

Parts:
C1: 10u; Potentiometer_Piher_PT-10-H05_Horizontal
C2: 10u; CP_Radial_Tantal_D5.0mm_P5.00mm
C3, C4, C9, C10, C11, C12: 1u; C_Rect_L10.3mm_W5.0mm_P7.50mm_MKS4
C5, C6: 100n; C_Rect_L10.0mm_W2.5mm_P7.50mm_MKS4
C7, C8, C13, C14: 1u; C_Disc_D5.1mm_W3.2mm_P5.00mm
J1: +20; Pin_d1.0mm_L10.0mm
J2: GND; Pin_d1.0mm_L10.0mm
J3: -20; Pin_d1.0mm_L10.0mm
J4: L In+; Pin_d1.0mm_L10.0mm
J5: L In-; Pin_d1.0mm_L10.0mm
J6: R In+; Pin_d1.0mm_L10.0mm
J7: R In-; Pin_d1.0mm_L10.0mm
J8: L Out+; 216843-1
J9: L Out-; 216843-1
J10: R Out+; 216843-1
J11: R Out-; 216843-1
R1, R2, R20, R21: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R5: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R6, R7, R8, R14, R15, R16, R17: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10: 1k5; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11: 100k; Potentiometer_Piher_PC-16_Dual_Horizontal
R12, R13: 15k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18, R19: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 10k; Potentiometer_Trimmer_Piher_PT-10h2.5_Vertical_Px2.5mm_Py5.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
U1: L7815; TO-220-3_Vertical
U2: L7915; TO-220-3_Vertical
U3, U4: OPA2134; DIP-8_W7.62mm

Connections:
+15V: C5.1, C7.2, C13.2, U1.3 (OUT), U3.8 (V+), U4.8 (V+)
-15V: C6.2, C8.2, C14.2, U2.3 (VO), U3.4 (V-), U4.4 (V-)
/L_in: C3.2, J4.1
/R_in: C4.2, J6.1
GND: C1.2, C2.1, C5.2, C6.1, C7.1, C8.1, C13.1, C14.1, J2.1, J5.1, J7.1, J9.1, J11.1, R1.2, R2.2, R4.2, R6.2, R11.3, R11.6, R12.2, R13.2, R14.2, R15.2, R20.2, R21.2, RV1.2, U1.2 (GND), U2.1 (GND)
unnamed: C1.1, J1.1, U1.1 (IN)
unnamed: C2.2, J3.1, U2.2 (VI)
unnamed: C3.1, R1.1, R3.2
unnamed: C4.1, R2.1, R5.2
unnamed: C9.1, C10.1, J8.1, R20.1
unnamed: C9.2, C10.2, R18.1
unnamed: C11.1, C12.1, J10.1, R21.1
unnamed: C11.2, C12.2, R19.1
unnamed: R3.1, U3.3 (+)
unnamed: R4.1, R7.2, U3.2 (-)
unnamed: R5.1, U4.3 (+)
unnamed: R6.1, R8.2, U4.2 (-)
unnamed: R7.1, R9.2, U3.1
unnamed: R10.1, R11.4, RV1.3
unnamed: R8.1, R10.2, U4.1
unnamed: R9.1, R11.1, RV1.1
unnamed: R11.2, R12.1, U3.5 (+)
unnamed: R11.5, R13.1, U4.5 (+)
unnamed: R14.1, R16.2, U3.6 (-)
unnamed: R15.1, R17.2, U4.6 (-)
unnamed: R16.1, R18.2, U3.7
unnamed: R17.1, R19.2, U4.7

Notes on the sheet:
Stage 1: 6dB gain
Stage 2: 6dB gain

Board: 2 copper layers, 83.0 x 54.0 mm, 51 parts (0 on the bottom side), 27 nets.

## KiCad design Power/Power.kicad_pcb

Parts:
C1, C2: 1000u; B43511-B9108-M
C3, C4: C; C_Rect_L11.5mm_W5.1mm_P10.00mm_MKT
D1: PLB405; Diode_Bridge_Vishay_KBL
J1: Trafo; PhoenixContact_MC_1,5_3-GF-3.5_1x03_P3.50mm_Horizontal_Thre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
J2: Power L; PhoenixContact_MC_1,5_3-GF-3.5_1x03_P3.50mm_Horizontal_Thre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
J3: Power R; PhoenixContact_MC_1,5_3-GF-3.5_1x03_P3.50mm_Horizontal_Thre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
J4: Power Preamp; PhoenixContact_MC_1,5_3-GF-3.5_1x03_P3.50mm_Horizontal_Thre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
R1, R2: 100K; R_Axial_DIN0414_L11.9mm_D4.5mm_P20.32mm_Horizontal

Connections:
+24V: C1.1, C3.1, D1.1 (+), J2.3, J3.3, J4.3, R1.1
-24V: C2.2, C4.2, D1.4 (-), J2.1, J3.1, J4.1, R2.2
GND: C1.2, C2.1, C3.2, C4.1, J1.2, J2.2, J3.2, J4.2, R1.2, R2.1
unnamed: D1.2 (~~), J1.1
unnamed: D1.3 (~~), J1.3

Board: 2 copper layers, 102.6 x 105.7 mm, 11 parts (0 on the bottom side), 5 nets.

## Commit log

2019-01-06 init
2019-01-06 finished sch
2019-01-09 set proper BJTs
2019-01-10 found power resistors
2019-01-10 fixed BJT footprints, started placement
2019-01-17 preliminary placement, caps missing
2019-01-17 connectors and fuses added
2019-01-17 placement done
2019-01-17 mounting holes
2019-01-18 routed
2019-01-20 silkscreen
2019-01-21 in/out connectors, silkscreen check
2019-01-21 ordered from jlcpcb
2019-02-15 .simulation works fine
2019-02-18 fixed Q9 and simulation
2019-05-08 preamp design started
2019-05-09 preamp footprints
2019-05-10 routing finished
2019-05-10 silkscreen, preorder ready
2019-05-10 ordered
2019-08-25 added rectifier circuit
2020-03-21 put actual mounting holes insted of vias in Power pcb
2020-03-23 fixed libraries, now works everything, including 3d models
